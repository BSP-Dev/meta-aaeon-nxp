## conf/machine/include/ucom-imx93-a10-0002.inc
```bitbake
# uCOM-iMX93-A10-0002 common machine configuration

MACHINEOVERRIDES =. "ucom-imx93-a10-0002:"
```
